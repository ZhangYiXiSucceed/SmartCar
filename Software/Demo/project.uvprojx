# Keil uVision project project.uvprojx, settings and files
target rtthread (6180000::V6.18::ARMCLANG)
  device: CY8C624ALQI-S2D42:Cortex-M4 Cypress
  pack: Cypress.PSoC6_DFP.1.2.0
  cpu: IRAM(0x08000000,0x100000) IROM(0x10000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CORE_NAME_CM0P_0, COMPONENT_CAT1, __RTTHREAD__, COMPONENT_CAT1A, CY_USING_HAL, RT_USING_ARMLIBC, RT_USING_LIBC, __STDC_LIMIT_MACROS, CORE_NAME_CM4_0, __CLK_TCK=RT_TICK_PER_SECOND, CY_USING_PREBUILT_CM0P_IMAGE, CY8C624ALQI_S2D42
  c include: rt-thread\components\libc\posix\ipc;libraries\HAL_Drivers;rt-thread\components\libc\posix\io\poll;libraries\IFX_PSOC6_HAL\retarget-io;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\io\stdio;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include;rt-thread\components\drivers\include;.;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\devices\COMPONENT_CAT1A\include;libs\TARGET_RTT-062S2;libs\TARGET_RTT-062S2\config\GeneratedSource;rt-thread\components\finsh;libraries\HAL_Drivers\config;libraries\IFX_PSOC6_HAL\mtb_shared\serial-flash;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\cmsis\include;libraries\IFX_PSOC6_HAL\mtb_shared\csdidac;libraries\IFX_PSOC6_HAL\mtb_shared\usbdev;rt-thread\include;libraries\IFX_PSOC6_HAL\core-lib\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\cortex-m4;board\ports;board;rt-thread\components\libc\compilers\common\include;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\COMPONENT_CAT1A\include;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\drivers\include;applications;rt-thread\components\drivers\include;libraries\IFX_PSOC6_HAL\psoc6cm0p;libraries\IFX_PSOC6_HAL\capsense;rt-thread\components\drivers\include;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include_pvt;rt-thread\components\libc\compilers\common\extension
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x100000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/TOOLCHAIN_ARM/: cy_syslib_ext.S
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    rt-thread/components/finsh/: msh_parse.c msh.c cmd.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/IFX_PSOC6_HAL/psoc6cm0p/COMPONENT_CM0P_SLEEP/: psoc6_03_cm0p_sleep.c psoc6_04_cm0p_sleep.c psoc6_02_cm0p_sleep.c psoc6_01_cm0p_sleep.c
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/: cy_trigmux.c cy_sysclk.c cy_prot.c cy_ipc_pipe.c cy_ipc_sema.c cy_systick.c cy_gpio.c cy_mcwdt.c cy_syspm.c cy_scb_common.c cy_scb_uart.c cy_sysint.c cy_ipc_drv.c cy_syslib.c cy_scb_i2c.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/source/: cyhal_gpio.c cyhal_system.c cyhal_irq_impl.c cyhal_clock.c cyhal_utils_impl.c cyhal_interconnect.c cyhal_hwmgr.c cyhal_uart.c cyhal_scb_common.c cyhal_utils.c cyhal_syspm.c cyhal_lptimer.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/triggers/: cyhal_triggers_psoc6_02.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/pin_packages/: cyhal_psoc6_02_68_qfn.c
    libraries/IFX_PSOC6_HAL/retarget-io/: cy_retarget_io.c
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/devices/COMPONENT_CAT1A/source/: cy_device.c
  group libs
    libs/TARGET_RTT-062S2/COMPONENT_CM4/TOOLCHAIN_ARM/: startup_psoc6_02_cm4.S
    libs/TARGET_RTT-062S2/config/GeneratedSource/: cycfg_clocks.c cycfg.c cycfg_capsense.c cycfg_pins.c cycfg_peripherals.c cycfg_routing.c cycfg_system.c cycfg_qspi_memslot.c
    libs/TARGET_RTT-062S2/COMPONENT_CM4/: system_psoc6_cm4.c
    libs/TARGET_RTT-062S2/: cybsp.c
